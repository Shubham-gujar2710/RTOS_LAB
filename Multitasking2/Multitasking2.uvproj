# Keil uVision project Multitasking2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Multitasking2 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  scatter file: .\ScatterFile.sct
  group app
    ./app/: adc.c app.c hook.c init.s kbd.c lcd.c LED.c Startup.s stepper.c UART.c vectors.s
  group include
    ./include/: app_cfg.h bsp.h cpu.h cpu_def.h func.h includes.h iolpc2148.h lib_def.h lib_mem.h lib_str.h os_cfg.h os_cpu.h ucos_ii.h
  group ucos
    ./uCOS-II/: bsp.c cpu_a.s lib_mem.c lib_str.c os_core.c os_cpu_a.asm os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
